# Keil uVision project gpio-scratch.uvprojx, settings and files
target stm32 (6180000::V6.18::ARMCLANG)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gpio-scratch
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ./: main.c
  group drivers
    ./: gpio.c gpio.h
  group lib
    ./: gpio_lib.h gpio_lib.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
